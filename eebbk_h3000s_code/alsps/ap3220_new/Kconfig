## eebbk_h5000_code/alsps/ls_ap3220/Kconfig
```kconfig
config MTK_LS_AP3220
	bool "light sensor ap3220"
	default y
	help
	 bbk light sensor 
```
